# Keil uVision project USB_PMBUS_BRIDGE.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: TUSB2136 +hex
  AfterMake: hex2bin TUSB2136.hex TUSB2136.bin
  AfterMake: stkkk.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: WORK_AROUND_192
  group Source Group 1
    ./: usbinit.c descrip.c main.c usb.c STARTUP.A51 serial.h serial.c
