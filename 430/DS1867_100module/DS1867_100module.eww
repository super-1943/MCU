<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DS1867_100module.ewp</path>
  </project>
  <batchBuild/>
</workspace>


