<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x4e32;&#x53e3;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


