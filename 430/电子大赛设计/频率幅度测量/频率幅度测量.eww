<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x9891;&#x7387;&#x5e45;&#x5eA6;&#x6D4B;&#x91CF;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


